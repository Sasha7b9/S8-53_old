# Keil uVision project Device53.uvprojx, settings and files
target Device53 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F217IGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Device53
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32F207xx, S8_53, OSCI
  c misc: --diag_suppress=161
  c include: ..\libs\STM32Cube_F2\Drivers\CMSIS\Include;..\libs\STM32Cube_F2\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\libs\STM32Cube_F2\Drivers\STM32F2xx_HAL_Driver\Inc;..\libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\libs\STM32Cube_F2\Middlewares\Third_Party\FatFs\src;..\libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\libs\STM32Cube_F2\Middlewares\Third_Party\LwIP\src\include;..\libs\STM32Cube_F2\Middlewares\Third_Party\LwIP\system;..\libs\STM32Cube_F2\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\libs\FatFS;.\src\libs\HAL;.\src\libs\LwIP;.\src\libs\USBD;.\src\libs\USBH;..\libs\common;..\libs\common\S8-53
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Device53.sct
  link misc: --diag_suppress=L6776W
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f207xx.s system_stm32f2xx.c
  group libs/FatFS
    ../libs/STM32Cube_F2/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../libs/STM32Cube_F2/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c usbh_diskio.h
    ../libs/STM32Cube_F2/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ./src/libs/FatFS/: ffconf.h
  group libs/HAL
    ../libs/STM32Cube_F2/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hcd.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_usb.c
    ./src/libs/HAL/: stm32f2xx_hal_conf.h stm32f2xx_hal_msp.cpp
  group libs/LwIP
    ../libs/STM32Cube_F2/Middlewares/Third_Party/LwIP/src/core/: udp.c tcp_in.c tcp_out.c tcp.c sys.c stats.c raw.c pbuf.c netif.c memp.c mem.c init.c dns.c inet_chksum.c def.c ip.c timeouts.c
    ../libs/STM32Cube_F2/Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4.c igmp.c icmp.c autoip.c dhcp.c etharp.c ip4_frag.c
    ../libs/STM32Cube_F2/Middlewares/Third_Party/LwIP/src/api/: tcpip.c sockets.c netdb.c netbuf.c err.c api_msg.c api_lib.c
    ../libs/STM32Cube_F2/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ./src/libs/LwIP/: app_ethernet.cpp app_ethernet.h ethernetif.cpp ethernetif.h lwipopts.h
  group libs/USBD
    ../libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ./src/libs/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_desc.h usbd_desc.cpp
  group libs/USBH
    ../libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ./src/libs/USBH/: usbh_conf.cpp usbh_conf.h
  group src
    ./src/: defines.h main.h main2.s Tables.h Globals.cpp main.cpp Tables.cpp
    ../libs/common/: Log.cpp Log.h
  group Display
    ./src/Display/: Display.cpp Display.h PainterMem.h Symbols.h PainterMem.cpp DisplayTypes.h
    ../libs/common/Display/: Colors.cpp Colors.h Grid.cpp Grid.h Painter.cpp Painter.h PainterText.cpp DisplayPrimitives.cpp DisplayPrimitives.h PainterPIC24.cpp PainterTextPIC24.cpp
  group Display/font
    ./src/Display/font/: Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc Font.cpp
  group Ethernet
    ./src/Ethernet/: Ethernet.h TcpSocket.h Ethernet.cpp TcpSocket.cpp
  group FlashDrive
    ./src/FlashDrive/: FlashDrive.cpp FlashDrive.h FileManager.cpp FileManager.h
  group FPGA
    ./src/FPGA/: DataStorage.cpp DataStorage.h FPGA.cpp FPGA.h FPGACalibration.cpp FPGASettings.cpp FPGATypes.h
    ../libs/common/FPGA/: FPGAMath.cpp FPGAMath.h
  group Hardware
    ./src/Hardware/: ADC.cpp ADC.h CPU.cpp CPU.h CPU_It.cpp CPU_Rtc.cpp FLASH.h FSMC.h Hardware.h FLASH.cpp FSMC.cpp Hardware.cpp MSP_USBH.cpp Panel.cpp Panel.h PanelFunctions.cpp CPU_VCP.cpp CPU_VCP.h
    ../libs/common/S8-53/Hardware/: Controls.cpp Controls.h
    ../libs/common/Hardware/: Timer.cpp Timer.h Sound.cpp Sound.h
  group Hardware/stm32
    ../libs/common/Hardware/stm32/: stm32.cpp stm32.h stm32_it.cpp
    ../libs/common/Hardware/stm32/207/: stm207.cpp stm207.h
    ../libs/common/Hardware/stm32/2XX/: Timer2XX.cpp Timer2XX.h
  group Menu
    ../libs/common/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuItemsDefs.h MenuItemsGraphics.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./src/Menu/Pages/: HelpContent.h HelpContentPages.h PageCursors.h PageHelp.h PageMemory.h HelpContent.cpp PageChannels.cpp PageCursors.cpp PageDebug.cpp PageDisplay.cpp PageHelp.cpp PageMeasures.cpp PageMemory.cpp PageService.cpp PageTime.cpp PageTrig.cpp PageChannels.h PageTrig.h PageDebug.h
    ../libs/common/Menu/Pages/: Definition.cpp Definition.h
  group SCPI
    ../libs/common/SCPI/: channelSCPI.cpp commonSCPI.cpp commonSCPI.h controlSCPI.cpp controlSCPI.h displaySCPI.cpp SCPI.cpp SCPI.h tbaseSCPI.cpp trigSCPI.cpp
  group Settings
    ./src/Settings/: Settings.h SettingsChannel.h SettingsCursors.h SettingsDebug.h SettingsDisplay.h SettingsMath.h SettingsMeasures.h SettingsMemory.h SettingsService.h SettingsTime.h SettingsTrig.h SettingsTypes.h Settings.cpp SettingsChannel.cpp SettingsCursors.cpp SettingsDebug.cpp SettingsDisplay.cpp SettingsMeasures.cpp SettingsMemory.cpp SettingsService.cpp SettingsTime.cpp
  group Utils
    ./src/Utils/: ProcessingSignal.h ProcessingSignal.cpp Dictionary.cpp Dictionary.h
    ../libs/common/Utils/: Math.cpp Math.h StringUtils.cpp StringUtils.h CommonFunctions.cpp CommonFunctions.h Map.cpp Map.h Measures.cpp Measures.h
