# Keil uVision project Loader53-Open7XX.uvprojx, settings and files
target Loader53 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: S8-53
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F746xx, __cplusplus, S8_53
  c misc: --cpp
  c include: ..\libs\STM32Cube_F7\Drivers\CMSIS\Include;..\libs\STM32Cube_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\libs\STM32Cube_F7\Drivers\STM32F7xx_HAL_Driver\Inc;..\libs\STM32Cube_F7\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\libs\STM32Cube_F7\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\libs\STM32Cube_F7\Middlewares\Third_Party\FatFs\src;..\libs\STM32Cube_F7\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\libs;..\libs\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Loader53.sct
  group Display
    ./src/Display/: Display.cpp Display.h
    ../libs/common/Display/: Colors.cpp Colors.h Painter.cpp Painter.h PainterText.cpp
  group FatFS
    ../libs/STM32Cube_F7/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../libs/STM32Cube_F7/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group FlashDrive
    ./src/FlashDrive/: FlashDrive.cpp FlashDrive.h usbh_diskio.c usbh_diskio.h
  group HAL
    ../libs/STM32Cube_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group Hardware
    ./src/Hardware/: FLASH.cpp FLASH.h FSMC.cpp FSMC.h Hardware.cpp Hardware.h
    ../libs/common/Hardware/: Timer.cpp Timer.h
  group libs
    ./src/libs/: ffconf.h startup_stm32f207xx.s stm32f7xx_hal_conf.h stm32f7xx_hal_msp.cpp stm32f2xx_it.cpp stm32f2xx_it.h usbh_conf.cpp usbh_conf.h system_stm32f7xx.c
  group Panel
    ./src/Panel/: Controls.cpp Controls.h Panel.cpp Panel.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h SettingsTypes.h
  group src
    ./src/: defines.h globals.cpp globals.h main.cpp main.h Log.h
    ../libs/common/: commonDefines.cpp commonDefines.h structs.h
  group USBH
    ../libs/STM32Cube_F7/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../libs/STM32Cube_F7/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../libs/STM32Cube_F7/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_def.h usbh_ioreq.h usbh_pipes.h
    ../libs/STM32Cube_F7/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
  group Utils
    ../libs/common/Utils/: Dictionary.cpp Dictionary.h Math.cpp Math.h StringUtils.cpp StringUtils.h
  group Display/fonts
    ./src/Display/font/: Font.cpp Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
  group FPGA
    ./src/FPGA/: FPGATypes.h
